# IAR project Project.ewp, settings and files
configuration S32F030K6_SENS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030K6 ST STM32F030K6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030x6; USE_HAL_DRIVER; USE_STM32F0XX_NUCLEO
  ICCARM.CCIncludePath2: ..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include; ..\..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\..\Drivers\BSP\STM32F0xx-BSP; ..\..\Drivers\BSP\Components\Common; ..\..\Drivers\BSP\Components\HC-SR04; ..\..\Drivers\BSP\Components\sht20
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F030R8-Nucleo.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f030x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/HC-SR04/: hcsr04.c
    ../../Drivers/BSP/Components/sht20/: sht20.c
  group Drivers/BSP/STM32F0xx-BSP
    ../../Drivers/BSP/STM32F0xx-BSP/: stm32f0xx_bsp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_timebase_rtc_alarm_template.c stm32f0xx_hal_timebase_rtc_wakeup_template.c stm32f0xx_hal_timebase_tim_template.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c
  group Example/EWARM
    ./: startup_stm32f030x6.s
  group Example/User
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
